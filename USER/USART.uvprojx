# Keil uVision project USART.uvprojx, settings and files
target USART (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: The Warriors V1.0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\FWLIB\inc;..\HARDWARE\LCD;..\HARDWARE\PWM;..\HARDWARE\SENSOR;..\HARDWARE\TIMER;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\COMPASS_NST;..\HARDWARE\SERVOR_BC;..\USER;..\HARDWARE\Camera
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: stm32f4xx_it.c system_stm32f4xx.c init.c main.c RobotInit.c AD_Detection.c ysy.c edge.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/SENSOR/: sensor.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/SERVOR_BC/: servor_bc.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/COMPASS_NST/: compass_nst.c
    ../HARDWARE/Camera/: Camera.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_adc.c
  group README
    ../: readme.txt
